Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-06-21T16:13:00
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jun 21 16:13:00 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{6DECAB51-4BE0-48B5-BD3D-9F4B868B1F47}\ifc * Database version: 5507 * Database creation date: Tue Jun 21 16:12:59 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jun 21 16:12:59 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jun 21 16:12:59 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFurnishingElement: Cork D, Vitra-Stools_and_Benches-Cork_D:Cork D:294541
In: Level 1
Type - Material: Untreated cork
Type - General - Author: BIMStone; BIMObjectName: Vitra-Stools_and_Benches-Cork_D; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The robust members of the Cork Family stand firmly, making them suited for use as side tables or stools. They benefit from the advantageous natural properties of cork: comparatively lightweight and extremely durable, they also have a velvety surface that is pleasant to touch.; Revision: n/a; Uniclass2: Pr_40_50_12_83; Uniclass2015Description: Stools; Uniclass2015Reference: Pr_40_50_12_85; Version: 1; VersionDate: 21/06/2022
Type - Identity Data - Cost: 0; Description: The robust members of the Cork Family stand firmly, making them suited for use as side tables or stools. They benefit from the advantageous natural properties of cork: comparatively lightweight and extremely durable, they also have a velvety surface that is pleasant to touch.; Design: Jasper Morrison; Manufacturer: Vitra; Model: Cork D; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Cork D; URL: https://www.vitra.com/en-be/living/product/details/cork-family-model-d
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Stools_and_Benches-Cork_D; Features: n/a; Finish: n/a; Grade: n/a; Material: Cork; ModelNumber: 21064601; ModelReference: n/a; Name: Cork_D; ReplacementCost: n/a; Shape: Sculptured; Size: 310x310x330 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.3007 m2; Volume: 0.031713 m3
Materials and Finishes - StoolMainMaterial: Untreated cork
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Stools_and_Benches-Cork_D: Cork D; Family and Type: Vitra-Stools_and_Benches-Cork_D: Cork D; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Stools_and_Benches-Cork_D: Cork D; Type Id: Vitra-Stools_and_Benches-Cork_D: Cork D; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
